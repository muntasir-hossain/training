SUMMARY = "Games"
PR = "r0"

inherit packagegroup

RDEPENDS_${PN} = "ninvaders"
